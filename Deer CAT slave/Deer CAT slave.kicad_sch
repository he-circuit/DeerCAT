File: Deer CAT slave/Deer CAT slave.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: 個人開発へ移行
Other:
- removed sheet LAN9252
- removed sheet Port0
- removed sheet Port1
